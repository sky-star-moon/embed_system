# Keil uVision project GAME.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: GAME +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 GAME.c LED_segment.h KEY.h Uart.h Data.h M485.h ADC.h Beep.h Real_Time.h ModBus_Base_Layer.h ModBus_High_Layer.h ModBus_Mid_Layer.h EEPROM.h
